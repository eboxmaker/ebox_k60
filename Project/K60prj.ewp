# IAR project K60prj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\Libraries\CMSIS\Include; ..\Libraries\devices; ..\Libraries\devices\MK60D10\startup; ..\Libraries\devices\MK60D10\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Libraries\devices\MK60D10\include
  OBJCOPY.OOCOutputFile: K60prj.srec
  ILINK.IlinkOutputFile: K60prj.out
  ILINK.IlinkIcfFile: ..\Libraries\devices\MK60D10\linker\iar\MK60DN512xxx10_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../Libraries/devices/: startup.c
    ../Libraries/devices/MK60D10/startup/iar/: startup_MK60D10.s
    ../Libraries/devices/MK60D10/startup/: system_MK60D10.c
  group ebox
    ../ebox/: ebox_core.cpp ebox_gpio.cpp ebox_object.cpp ebox_port.cpp ebox_sim.cpp ebox_uart.cpp
  group user
    ../user/: Blinky.cpp
